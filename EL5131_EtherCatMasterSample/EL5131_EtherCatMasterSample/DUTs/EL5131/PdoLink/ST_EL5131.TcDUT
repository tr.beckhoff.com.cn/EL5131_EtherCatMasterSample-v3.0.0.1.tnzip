TYPE ST_EL5131 :
STRUCT
	PdoToPlc		AT%I*			:	ST_EL5131_INPUT;
	PlcToPdo		AT%Q*			:	ST_EL5131_OUTPUT;
END_STRUCT
END_TYPE
